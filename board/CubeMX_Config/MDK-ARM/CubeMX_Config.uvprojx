# Keil uVision project CubeMX_Config.uvprojx, settings and files
target CubeMX_Config (ARM-ADS)
  device: STM32H743IITx STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF)      CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: CubeMX_Config +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Inc;       ../Drivers/STM32H7xx_HAL_Driver/Inc;       ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;       ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;       ../Drivers/CMSIS/Include; ../Src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../middlewares/st/touchgfx/framework/include;../src/generated/fonts/include;../src/generated/gui_generated/include;../src/generated/images/include;../src/generated/texts/include;../src/gui/include
  asm include: ..\Inc
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User
    ../Src/: main.c freertos.c TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp TouchGFXHAL.cpp STM32TouchController.cpp STM32DMA.cpp OSWrappers.cpp TouchGFXGPIO.cpp app_touchgfx.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ./: 
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group gui
    ../src/gui/src/common/: frontendapplication.cpp
    ../src/gui/src/model/: model.cpp
    ../src/gui/src/screen1_screen/: screen1presenter.cpp screen1view.cpp
    ../src/gui/src/screen2_screen/: screen2presenter.cpp screen2view.cpp
  group generated
    ../src/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_gb2312_25_4bpp_0.cpp font_gb2312_25_4bpp_19.cpp font_gb2312_25_4bpp_9.cpp font_verdana_10_4bpp_0.cpp font_verdana_20_4bpp_0.cpp font_verdana_40_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_gb2312_25_4bpp.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_40_4bpp.cpp table_gb2312_25_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_40_4bpp.cpp
    ../src/generated/images/src/: bitmapdatabase.cpp rttpicture.cpp
    ../src/generated/images/src/__designer/: blue_buttons_round_edge_small.cpp blue_buttons_round_edge_small_pressed.cpp blue_clocks_backgrounds_clock_classic_background.cpp blue_clocks_hands_clock_standard_hour_hand.cpp blue_clocks_hands_clock_standard_minute_hand.cpp blue_clocks_hands_clock_standard_second_hand.cpp
    ../src/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../src/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../src/generated/gui_generated/src/screen1_screen/: screen1viewbase.cpp
    ../src/generated/gui_generated/src/screen2_screen/: screen2viewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
software components: CMSIS:CORE 4.3.0
